# Keil uVision project stm32f469_rtos.uvprojx, settings and files
target STM32F469NIH (6220000::V6.22::ARMCLANG)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: stm32f469_rtos
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group inc
    ./: gpio.h
  group src
    ./: main.c gpio.c
  group Device
    ./RTE/Device/: startup_stm32f469xx.s system_stm32f4xx.c
  group FRTOS
    ./: kernel.h kernel.s
software components: CMSIS:CORE 6.2.0
